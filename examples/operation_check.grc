options:
  parameters:
    author: Atsushi Nakamura
    generate_options: no_gui
    id: operation_chack
    output_language: python
    realtime_scheduling: '1'
    title: Operation check
  states: {}

blocks:
- name: code_definition
  id: variable
  parameters:
    value: '4'
  states: {}
- name: number_of_bits
  id: variable
  parameters:
    value: '8'
  states: {}
- name: os_factor
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: sliding_width
  id: variable
  parameters:
    value: '32'
  states: {}
- name: subslot_width
  id: variable
  parameters:
    value: '128'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: apcma_sdr_apcma_rx_0
  id: apcma_sdr_apcma_rx
  parameters:
    N_bits: number_of_bits
    code_def: code_definition
    os_factor: os_factor
    samp_rate: samp_rate
    sf: sf
    sliding_width: sliding_width
    subslot_width: subslot_width
    threshold: threshold
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', apcma_sdr_apcma_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
