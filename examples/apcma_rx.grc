options:
  parameters:
    author: Atsushi Nakamura
    generate_options: no_gui
    id: apcma_rx
    output_language: python
    title: APCMA receiving program
  states: {}

blocks:
- name: code_definition
  id: variable
  parameters:
    value: '4'
  states: {}
- name: number_of_bits
  id: variable
  parameters:
    value: '8'
  states: {}
- name: os_factor
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: sliding_width
  id: variable
  parameters:
    value: '32'
  states: {}
- name: subslot_width
  id: variable
  parameters:
    value: '128'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: apcma_sdr_apcma_rx_0
  id: apcma_sdr_apcma_rx
  parameters:
    N_bits: number_of_bits
    code_def: code_definition
    os_factor: os_factor
    samp_rate: samp_rate
    sf: sf
    sliding_width: sliding_width
    subslot_width: subslot_width
    threshold: threshold
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate / os_factor
    center_freq0: 920e6
    gain0: '50'
    minoutbuf: 2**(sf+2)
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', apcma_sdr_apcma_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
